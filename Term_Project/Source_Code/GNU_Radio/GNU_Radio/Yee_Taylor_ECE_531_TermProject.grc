options:
  parameters:
    generate_options: qt_gui
    id: TY_TermProject_ECE531
    output_language: python
    title: 'Term Project: BPM with SDR'
  states: {}

blocks:
- name: fm_station
  id: variable_qtgui_range
  parameters:
    label: FM Station
    start: 88.1e6
    step: 200e3
    stop: 107.5e6
    value: 93.7e6
  states: {}
- name: gain_fm_demod
  id: variable_qtgui_range
  parameters:
    label: gain_fm_demod
    start: '0'
    step: '1'
    stop: '50'
    value: '1'
  states: {}
- name: gain_lpf
  id: variable_qtgui_range
  parameters:
    label: gain_lpf
    start: '0'
    step: '1'
    stop: '50'
    value: '1'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 2.304e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '100e-3'
    stop: '1'
    value: '700e-3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '12'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: 384e3
    deviation: '75000'
    gain: gain_fm_demod
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: youshookmeallnightlong_acdc
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: fm_station
    freq_span: sample_rate
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: fm_station
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: usb:2.2.5
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '4'
    gain: gain_lpf
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: 48e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: fm_station
    fftsize: '1024'
    name: Received FM Spectrum - Demod
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: fm_station
    fftsize: '1024'
    name: Received Spectrum
    type: complex
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', fosphor_qt_sink_c_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
